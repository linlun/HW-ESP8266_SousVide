# Repository linlun/HW-ESP8266_SousVide

File README.md:

# HW-ESP8266_SousVide
The schematics and layout for a Sous vide controler PCB made in Kicad

## KiCad design SousVide.kicad_pcb

Parts:
C1, C3, C4, C5, C6: 100n; C_0603
C2, C8, C9: 1u; C_0805
C7: 4u7; C_0805
DC1: DCDC_module
DISP1: OLED_i2c_Display_0.99inch; OLED_i2c_0.99inch
E1: Encoder_switch; encoder_alps-ec12d
L1, L2: PP_WS2812B; WS2812B_PP
P1, P4, P6: CONN_01X03; Pin_Header_Straight_1x03
P2: USB_OTG; conn_usb_B_micro_smd-lilu
P3: CONN_01X04; Pin_Header_Straight_1x04
P5: CONN_01X06; Pin_Header_Straight_1x06
R1, R2, R3, R4, R6, R7, R14: 4k7; R_0603
R5, R8, R10, R11, R12, R13, R15: 1k; R_0603
R9, R16: 7k5; R_0603
SW1, SW2: SMD SW; switch3x6_smd
U1: 74HCT125PW; TSSOP-14_4.4x5mm_Pitch0.65mm
U2: CP2102; QFN-28-1EP_5x5mm_Pitch0.5mm
U3: ESP-12
U4: MCP1700T-3302E/TT; SOT89-3_Housing

Connections:
+3V3: C7.1, C9.1, DC1.5 (Out), DC1.6 (Out), DISP1.4 (VCC), P4.1, P5.2, R1.2, R4.2, R6.2, R7.2, R16.1, U3.3 (CH_PD), U3.8 (VCC), U4.2
+5V: C1.1, C2.1, C8.1, DC1.3 (In), DC1.4 (In), L1.1 (VDD), L2.1 (VDD), P1.2, P2.1 (VCC), P3.1, P5.1, P6.1, U1.14 (VCC), U2.7, U2.8, U4.3
/ADC: P5.4, U3.2 (ADC)
/DTR: R10.1, U2.28
/GPIO_0: R15.2, U1.5 (D), U3.12 (GPIO0)
/GPIO_2: C4.1, R4.1, R5.1, U3.11 (GPIO2)
/GPIO_4: P4.3, P5.5, R1.1, U3.14 (GPIO5)
/GPIO_5: C6.1, R7.1, R12.1, U3.13 (GPIO4)
/GPIO_12: DISP1.1 (SDA), U3.6 (GPIO12)
/GPIO_13: DISP1.2 (SCL), U3.7 (GPIO13)
/GPIO_14: C5.1, R6.1, R11.1, U3.5 (GPIO14)
/GPIO_15: R14.2, U1.12 (D), U3.10 (GPIO15)
/GPIO_16: R2.2, R3.2, R13.1, U3.4 (GPIO16)
/LED: L1.4 (DIN), P5.3, U1.6 (O)
/RTS: R8.2, U2.24
/Rxd: R9.1, U2.26, U3.15 (RXD)
/Txd: U2.25, U3.16 (TXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, DC1.1 (GND), DC1.2 (GND), DC1.7 (GND), DC1.8 (GND), DISP1.3 (GND), E1.2, E1.5, L1.3 (VSS), L2.3 (VSS), P1.3, P2.5 (GND), P2.6 (shield), P3.4, P4.2, P5.6, P6.3, R3.1, R14.1, SW1.2, SW2.1, U1.1 (E), U1.2 (D), U1.4 (E), U1.7 (GND), U1.9 (D), U1.10 (E), U1.13 (E), U2.3, U3.9 (GND), U4.1
unnamed: C3.1, U2.6
unnamed: C7.2, R8.1, R9.2, R13.2, SW2.2, U3.1 (REST)
unnamed: E1.1, R11.2
unnamed: E1.3, R12.2
unnamed: E1.4, R5.2
unnamed: L1.2 (DOUT), L2.4 (DIN)
unnamed: L2.2 (DOUT), P6.2
unnamed: P1.1, U1.11 (O)
unnamed: P2.2 (D-), U2.5
unnamed: P2.3 (D+), U2.4
unnamed: P3.2, P3.3, R2.1
unnamed: R10.2, R15.1, R16.2, SW1.1

Notes on the sheet:
DS18B20
OLED Display
ESP8266
USB-UART
3v3 DC/DC regulator
433 MHz transceivers
TODO: footprint på LED är fel Byt ordning på P4 för att matcha pinout på ds18b20 Byt plats på SW för reset och bootloader (för att enklare trycka reset) Lägg till liten led som visar relästatus

Board: 2 copper layers, 70.0 x 32.0 mm, 42 parts (0 on the bottom side), 30 nets.

## Commit log

2016-11-21 Added the schematics, still i draft status and some files might be missing
